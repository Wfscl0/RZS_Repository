# IAR project Backup of project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ebyte\E220xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ebyte; ..\..\..\1_Middleware\Produce
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group board
    ../../../2_Ebyte_Board_Support/E15-EVB02/: board.c board_button.c board_mini_printf.c
  group drivers/ebyte
    ebyte/: ebyte_conf.h ebyte_core.c
  group drivers/ebyte/sub
    ebyte/E220xMx/: ebyte_callback.c ebyte_e220x.c ebyte_port.c
  group drivers/mcu
    ../../../4_STM8_L15x_StdPeriph_Drivers/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group main
    ./: main.c stm8l15x_it.c
  group middleware
    ../../../1_Middleware/Produce/: ebyte_debug.c
    ../../../1_Middleware/Kfifo/: ebyte_kfifo.c
