# Keil uVision project RES_Vehicle_G0B1.uvprojx, settings and files
target RES_Vehicle_G0B1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G0B1CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x08000000-0x0801FFFF) CLOCK(64000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: RES_Vehicle_G0B1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../../shared/include
  group Application/Core
    ../Core/Src/: main.c fdcan.c gpio.c iwdg.c usart.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c
  group Application/RES
    ../Core/Src/: res_protocol_build.c res_can_contract_build.c res_vehicle_app.c res_vehicle_stm32_port.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_rcc.c
  group Startup
    ./: startup_stm32g0b1xx.s
